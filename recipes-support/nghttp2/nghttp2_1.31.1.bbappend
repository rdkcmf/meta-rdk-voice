FILES_${PN}-common += "${libdir}/libnghttp2.so.14"
