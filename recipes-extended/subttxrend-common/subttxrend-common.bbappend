DEPENDS += "asio"
RDEPENDS_${PN} += "asio"
