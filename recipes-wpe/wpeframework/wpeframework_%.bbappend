FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

WPEFRAMEWORK_EXCEPTIONS_ENABLE = "ON"
ASNEEDED=""

