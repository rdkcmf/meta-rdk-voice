FILESEXTRAPATHS_prepend := "${THISDIR}/wpeframework:"

ASNEEDED=""

